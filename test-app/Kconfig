## test-app/Kconfig
```kconfig
source "Kconfig.zephyr"

config MYFUNCTION
    bool "Enable My Function"
    default n
```
